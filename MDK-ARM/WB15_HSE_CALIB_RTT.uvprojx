# Keil uVision project WB15_HSE_CALIB_RTT.uvprojx, settings and files
target WB15_HSE_CALIB_RTT (6180000::V6.18::ARMCLANG)
  device: STM32WB15CCUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x20030000-0x200327FF) IROM(0x8000000-0x8027FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WB15_HSE_CALIB_RTT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB15xx
  c include: ../Core/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include;..\Core\Config
  memory RVCT4: ROM 0x8000000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb15xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c rng.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/Core/RTT
    ../Core/Src/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rng.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDOUT 1.2.0
